!  08/07/2025  16:22:09
! Ref Plane: 0.000 mm
# MHZ S MA R  50
! Worked out from all points (one-port):
!   1001 points, 3.3 GHz to 6 GHz, reference 50 ohm
!   lowest |S11| = -46.3 dB at 3.324 GHz (marker M1), VSWR 1.01, Z = 50.4 - j0.324 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11
! 3.3 GHz  -45.0
! 3.324 GHz  -46.3
! 3.638 GHz  -35.2
! 3.667 GHz  -37.7
! 3.697 GHz  -34.7
! 3.975 GHz  -34.8
! 4.067 GHz  -37.3
! 4.099 GHz  -34.3
! 4.126 GHz  -37.5
! 4.159 GHz  -34.1
! 4.186 GHz  -37.6
! 4.218 GHz  -33.9
! 4.248 GHz  -37.5
! 4.277 GHz  -34.0
! 4.312 GHz  -36.9
! 4.396 GHz  -34.6
! 4.62 GHz  -36.3
! 4.65 GHz  -39.1
! 4.739 GHz  -37.4
! 4.771 GHz  -41.1
! 4.801 GHz  -37.9
! 4.831 GHz  -41.5
! 4.861 GHz  -38.1
! 4.89 GHz  -41.2
! 4.987 GHz  -37.6
! 5.325 GHz  -35.4
! 5.662 GHz  -35.7
! 6 GHz  -34.4
