!  31/07/2025  14:57:48
! Ref Plane: 0.000 mm
# MHZ S MA R  50
! Worked out from all points (one-port):
!   201 points, 3.5 GHz to 6 GHz, reference 50 ohm
!   lowest |S11| = -53.2 dB at 5.475 GHz (marker M1), VSWR 1.00, Z = 50.2 - j0.0638 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11
! 3.5 GHz  -42.7
! 3.525 GHz  -39.4
! 3.55 GHz  -41.8
! 3.638 GHz  -37.2
! 3.812 GHz  -36.4
! 4.013 GHz  -38.3
! 4.1 GHz  -34.7
! 4.125 GHz  -38.2
! 4.162 GHz  -34.5
! 4.188 GHz  -38.1
! 4.213 GHz  -34.1
! 4.25 GHz  -37.5
! 4.275 GHz  -33.7
! 4.3 GHz  -36.9
! 4.338 GHz  -33.6
! 4.362 GHz  -36.5
! 4.438 GHz  -34.7
! 4.625 GHz  -33.3
! 4.65 GHz  -36.5
! 4.675 GHz  -33.3
! 4.713 GHz  -37.0
! 4.75 GHz  -34.3
! 5.062 GHz  -39.4
! 5.375 GHz  -49.2
! 5.475 GHz  -53.2
! 5.5 GHz  -49.4
! 5.688 GHz  -43.2
! 6 GHz  -38.7
