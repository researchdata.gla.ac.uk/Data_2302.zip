!  08/07/2025  15:18:01
! Ref Plane: 0.000 mm
# MHZ S MA R  50
! Worked out from all points (one-port):
!   1001 points, 3.3 GHz to 6 GHz, reference 50 ohm
!   lowest |S11| = -44.1 dB at 3.327 GHz (marker M1), VSWR 1.01, Z = 50.5 - j0.35 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11
! 3.3 GHz  -42.8
! 3.327 GHz  -44.1
! 3.638 GHz  -33.0
! 3.667 GHz  -35.6
! 3.697 GHz  -32.5
! 3.975 GHz  -32.4
! 4.069 GHz  -34.6
! 4.099 GHz  -31.6
! 4.126 GHz  -34.8
! 4.159 GHz  -31.3
! 4.188 GHz  -34.7
! 4.218 GHz  -30.9
! 4.248 GHz  -34.4
! 4.277 GHz  -30.9
! 4.312 GHz  -33.7
! 4.337 GHz  -30.9
! 4.65 GHz  -33.9
! 4.739 GHz  -31.5
! 4.769 GHz  -35.2
! 4.798 GHz  -32.1
! 4.831 GHz  -35.9
! 4.861 GHz  -32.9
! 4.89 GHz  -36.6
! 4.987 GHz  -35.2
! 5.131 GHz  -37.8
! 5.325 GHz  -34.9
! 5.662 GHz  -33.6
! 6 GHz  -32.5
