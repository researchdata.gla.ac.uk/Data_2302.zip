!  08/07/2025  17:28:01
! Ref Plane: 0.000 mm
# MHZ S MA R  50
! Worked out from all points (one-port):
!   1001 points, 3.3 GHz to 6 GHz, reference 50 ohm
!   lowest |S11| = -48.6 dB at 3.324 GHz (marker M1), VSWR 1.01, Z = 50.3 - j0.275 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11
! 3.3 GHz  -47.3
! 3.324 GHz  -48.6
! 3.638 GHz  -37.6
! 3.667 GHz  -40.2
! 3.697 GHz  -37.1
! 3.975 GHz  -37.4
! 4.067 GHz  -40.0
! 4.099 GHz  -37.0
! 4.126 GHz  -40.2
! 4.159 GHz  -36.9
! 4.186 GHz  -40.5
! 4.218 GHz  -36.7
! 4.248 GHz  -40.4
! 4.277 GHz  -37.0
! 4.312 GHz  -39.9
! 4.337 GHz  -37.3
! 4.65 GHz  -42.2
! 4.739 GHz  -39.9
! 4.771 GHz  -43.3
! 4.801 GHz  -39.9
! 4.831 GHz  -43.4
! 4.861 GHz  -39.8
! 4.89 GHz  -43.0
! 4.92 GHz  -39.5
! 4.987 GHz  -39.4
! 5.325 GHz  -37.6
! 5.662 GHz  -37.7
! 6 GHz  -36.3
