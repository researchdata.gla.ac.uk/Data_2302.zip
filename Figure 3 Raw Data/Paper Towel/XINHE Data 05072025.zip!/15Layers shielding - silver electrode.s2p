!  08/07/2025  16:01:13
! Ref Plane: 0.000 mm
# MHZ S MA R  50
! Worked out from all points (one-port):
!   1001 points, 3.3 GHz to 6 GHz, reference 50 ohm
!   lowest |S11| = -45.6 dB at 3.324 GHz (marker M1), VSWR 1.01, Z = 50.4 - j0.344 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11
! 3.3 GHz  -44.3
! 3.324 GHz  -45.6
! 3.638 GHz  -34.4
! 3.667 GHz  -37.0
! 3.697 GHz  -33.9
! 3.975 GHz  -33.6
! 4.067 GHz  -35.9
! 4.099 GHz  -32.8
! 4.126 GHz  -36.0
! 4.159 GHz  -32.4
! 4.186 GHz  -35.9
! 4.218 GHz  -32.1
! 4.248 GHz  -35.7
! 4.277 GHz  -32.1
! 4.312 GHz  -35.0
! 4.337 GHz  -32.2
! 4.65 GHz  -36.4
! 4.739 GHz  -34.4
! 4.769 GHz  -38.2
! 4.798 GHz  -35.2
! 4.831 GHz  -39.3
! 4.861 GHz  -36.4
! 4.89 GHz  -40.3
! 4.987 GHz  -39.0
! 5.074 GHz  -41.1
! 5.325 GHz  -36.9
! 5.662 GHz  -36.2
! 6 GHz  -34.9
