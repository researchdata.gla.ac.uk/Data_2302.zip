!  08/07/2025  17:15:25
! Ref Plane: 0.000 mm
# MHZ S MA R  50
! Worked out from all points (one-port):
!   1001 points, 3.3 GHz to 6 GHz, reference 50 ohm
!   lowest |S11| = -47.4 dB at 3.327 GHz (marker M1), VSWR 1.01, Z = 50.3 - j0.278 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11
! 3.3 GHz  -46.1
! 3.327 GHz  -47.4
! 3.638 GHz  -36.1
! 3.667 GHz  -38.6
! 3.697 GHz  -35.5
! 3.975 GHz  -35.2
! 4.069 GHz  -37.5
! 4.099 GHz  -34.5
! 4.126 GHz  -37.7
! 4.159 GHz  -34.2
! 4.188 GHz  -37.7
! 4.218 GHz  -34.0
! 4.248 GHz  -37.6
! 4.277 GHz  -34.1
! 4.312 GHz  -37.0
! 4.337 GHz  -34.2
! 4.65 GHz  -38.4
! 4.739 GHz  -36.7
! 4.769 GHz  -40.6
! 4.798 GHz  -37.8
! 4.831 GHz  -42.1
! 4.861 GHz  -39.4
! 4.89 GHz  -43.6
! 4.987 GHz  -43.6
! 5.074 GHz  -46.6
! 5.325 GHz  -40.8
! 5.662 GHz  -39.0
! 6 GHz  -37.3
