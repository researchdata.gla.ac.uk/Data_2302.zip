!  08/07/2025  15:34:46
! Ref Plane: 0.000 mm
# MHZ S MA R  50
! Worked out from all points (one-port):
!   1001 points, 3.3 GHz to 6 GHz, reference 50 ohm
!   lowest |S11| = -44.6 dB at 3.324 GHz (marker M1), VSWR 1.01, Z = 50.5 - j0.358 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11
! 3.3 GHz  -43.3
! 3.324 GHz  -44.6
! 3.638 GHz  -33.5
! 3.975 GHz  -32.8
! 4.069 GHz  -35.1
! 4.099 GHz  -32.0
! 4.126 GHz  -35.2
! 4.159 GHz  -31.7
! 4.188 GHz  -35.2
! 4.218 GHz  -31.4
! 4.248 GHz  -35.0
! 4.277 GHz  -31.4
! 4.312 GHz  -34.3
! 4.337 GHz  -31.5
! 4.65 GHz  -34.8
! 4.68 GHz  -32.3
! 4.709 GHz  -35.6
! 4.742 GHz  -32.7
! 4.769 GHz  -36.3
! 4.801 GHz  -33.3
! 4.831 GHz  -37.1
! 4.861 GHz  -34.1
! 4.89 GHz  -37.8
! 4.987 GHz  -36.0
! 5.074 GHz  -37.9
! 5.325 GHz  -34.6
! 5.662 GHz  -34.1
! 6 GHz  -33.1
