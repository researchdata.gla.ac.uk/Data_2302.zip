!  08/07/2025  16:53:59
! Ref Plane: 0.000 mm
# MHZ S MA R  50
! Worked out from all points (one-port):
!   1001 points, 3.3 GHz to 6 GHz, reference 50 ohm
!   lowest |S11| = -47.2 dB at 3.324 GHz (marker M1), VSWR 1.01, Z = 50.3 - j0.3 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11
! 3.3 GHz  -45.9
! 3.324 GHz  -47.2
! 3.638 GHz  -36.1
! 3.667 GHz  -38.7
! 3.697 GHz  -35.6
! 3.727 GHz  -38.1
! 3.975 GHz  -35.5
! 4.067 GHz  -38.0
! 4.099 GHz  -35.0
! 4.126 GHz  -38.2
! 4.159 GHz  -34.8
! 4.186 GHz  -38.3
! 4.218 GHz  -34.6
! 4.248 GHz  -38.3
! 4.277 GHz  -34.8
! 4.312 GHz  -37.8
! 4.396 GHz  -35.6
! 4.65 GHz  -40.6
! 4.739 GHz  -38.9
! 4.771 GHz  -42.6
! 4.801 GHz  -39.4
! 4.831 GHz  -43.1
! 4.858 GHz  -39.7
! 4.89 GHz  -42.9
! 4.987 GHz  -39.3
! 5.325 GHz  -36.9
! 5.662 GHz  -37.2
! 6 GHz  -35.8
