!  31/07/2025  15:22:38
! Ref Plane: 0.000 mm
# MHZ S MA R  50
! Worked out from all points (one-port):
!   201 points, 3.5 GHz to 6 GHz, reference 50 ohm
!   lowest |S11| = -56.6 dB at 5.625 GHz (marker M1), VSWR 1.00, Z = 49.9 + j0.1 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11
! 3.5 GHz  -43.3
! 3.525 GHz  -39.9
! 3.55 GHz  -42.3
! 3.638 GHz  -37.6
! 3.812 GHz  -36.6
! 4.013 GHz  -38.5
! 4.037 GHz  -35.4
! 4.062 GHz  -38.2
! 4.1 GHz  -35.0
! 4.125 GHz  -38.5
! 4.162 GHz  -34.8
! 4.188 GHz  -38.4
! 4.213 GHz  -34.3
! 4.25 GHz  -37.7
! 4.275 GHz  -33.9
! 4.3 GHz  -37.1
! 4.338 GHz  -33.8
! 4.362 GHz  -36.7
! 4.438 GHz  -34.8
! 4.713 GHz  -36.7
! 4.75 GHz  -34.0
! 5.062 GHz  -37.1
! 5.375 GHz  -40.8
! 5.5 GHz  -46.1
! 5.625 GHz  -56.6
! 5.688 GHz  -51.1
! 5.838 GHz  -42.6
! 6 GHz  -40.4
