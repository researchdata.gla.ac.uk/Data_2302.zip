!  31/07/2025  12:05:25
! Ref Plane: 0.000 mm
# MHZ S MA R  50
! Worked out from all points (one-port):
!   201 points, 3.5 GHz to 6 GHz, reference 50 ohm
!   lowest |S11| = -49.2 dB at 5.35 GHz (marker M1), VSWR 1.01, Z = 50.3 - j0.168 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11
! 3.5 GHz  -42.9
! 3.525 GHz  -39.6
! 3.55 GHz  -41.9
! 3.638 GHz  -37.4
! 3.812 GHz  -36.6
! 4.013 GHz  -38.6
! 4.037 GHz  -35.5
! 4.062 GHz  -38.4
! 4.1 GHz  -35.2
! 4.125 GHz  -38.6
! 4.162 GHz  -35.0
! 4.188 GHz  -38.7
! 4.213 GHz  -34.7
! 4.25 GHz  -38.1
! 4.275 GHz  -34.4
! 4.3 GHz  -37.6
! 4.338 GHz  -34.4
! 4.362 GHz  -37.3
! 4.438 GHz  -35.6
! 4.65 GHz  -37.9
! 4.675 GHz  -34.8
! 4.713 GHz  -38.5
! 4.75 GHz  -36.0
! 5.062 GHz  -42.1
! 5.35 GHz  -49.2
! 5.375 GHz  -47.0
! 5.688 GHz  -41.1
! 6 GHz  -38.9
