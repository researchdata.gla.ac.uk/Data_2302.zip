!  08/07/2025  16:40:11
! Ref Plane: 0.000 mm
# MHZ S MA R  50
! Worked out from all points (one-port):
!   1001 points, 3.3 GHz to 6 GHz, reference 50 ohm
!   lowest |S11| = -47.0 dB at 3.324 GHz (marker M1), VSWR 1.01, Z = 50.3 - j0.309 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11
! 3.3 GHz  -45.8
! 3.324 GHz  -47.0
! 3.638 GHz  -35.8
! 3.667 GHz  -38.4
! 3.975 GHz  -35.2
! 4.067 GHz  -37.6
! 4.099 GHz  -34.5
! 4.126 GHz  -37.8
! 4.159 GHz  -34.3
! 4.188 GHz  -37.9
! 4.218 GHz  -34.1
! 4.248 GHz  -37.8
! 4.277 GHz  -34.3
! 4.312 GHz  -37.2
! 4.337 GHz  -34.5
! 4.367 GHz  -37.3
! 4.564 GHz  -36.3
! 4.65 GHz  -39.7
! 4.739 GHz  -38.6
! 4.769 GHz  -42.6
! 4.798 GHz  -40.0
! 4.828 GHz  -44.3
! 4.861 GHz  -41.7
! 4.89 GHz  -45.5
! 4.987 GHz  -42.7
! 5.325 GHz  -37.1
! 5.662 GHz  -36.5
! 6 GHz  -35.6
