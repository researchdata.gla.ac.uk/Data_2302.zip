!  08/07/2025  15:49:19
! Ref Plane: 0.000 mm
# MHZ S MA R  50
! Worked out from all points (one-port):
!   1001 points, 3.3 GHz to 6 GHz, reference 50 ohm
!   lowest |S11| = -45.3 dB at 3.327 GHz (marker M1), VSWR 1.01, Z = 50.4 - j0.323 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11
! 3.3 GHz  -44.0
! 3.327 GHz  -45.3
! 3.638 GHz  -34.4
! 3.667 GHz  -37.0
! 3.697 GHz  -33.9
! 3.975 GHz  -34.1
! 4.067 GHz  -36.5
! 4.099 GHz  -33.5
! 4.126 GHz  -36.7
! 4.159 GHz  -33.2
! 4.186 GHz  -36.7
! 4.215 GHz  -33.0
! 4.248 GHz  -36.5
! 4.277 GHz  -33.0
! 4.312 GHz  -35.8
! 4.337 GHz  -33.0
! 4.65 GHz  -36.2
! 4.739 GHz  -33.6
! 4.771 GHz  -37.2
! 4.801 GHz  -33.8
! 4.831 GHz  -37.4
! 4.861 GHz  -34.0
! 4.89 GHz  -37.4
! 4.92 GHz  -34.3
! 4.987 GHz  -34.6
! 5.325 GHz  -33.7
! 5.662 GHz  -34.1
! 6 GHz  -32.9
