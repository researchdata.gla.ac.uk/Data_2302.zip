!  31/07/2025  14:17:12
! Ref Plane: 0.000 mm
# MHZ S MA R  50
! Worked out from all points (one-port):
!   201 points, 3.5 GHz to 6 GHz, reference 50 ohm
!   lowest |S11| = -48.4 dB at 5.537 GHz (marker M1), VSWR 1.01, Z = 50.3 - j0.2 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11
! 3.5 GHz  -42.8
! 3.525 GHz  -39.5
! 3.55 GHz  -41.9
! 3.575 GHz  -38.6
! 3.812 GHz  -36.5
! 4.013 GHz  -38.4
! 4.1 GHz  -34.8
! 4.125 GHz  -38.3
! 4.162 GHz  -34.6
! 4.188 GHz  -38.2
! 4.213 GHz  -34.2
! 4.25 GHz  -37.5
! 4.275 GHz  -33.8
! 4.3 GHz  -36.9
! 4.338 GHz  -33.6
! 4.362 GHz  -36.5
! 4.438 GHz  -34.6
! 4.625 GHz  -32.9
! 4.65 GHz  -36.1
! 4.675 GHz  -32.8
! 4.713 GHz  -36.4
! 4.75 GHz  -33.6
! 4.775 GHz  -36.4
! 5.062 GHz  -37.1
! 5.375 GHz  -42.7
! 5.537 GHz  -48.4
! 5.688 GHz  -43.8
! 6 GHz  -40.1
